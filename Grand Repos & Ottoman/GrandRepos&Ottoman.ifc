Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-31T16:33:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 31 16:33:39 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{C573710D-6C78-45CD-8F7C-93DED5EE7D1B}\ifc * Database version: 5507 * Database creation date: Thu Jan 31 16:33:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 31 16:33:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 31 16:33:38 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Grand Repos lounge chair & Ottoman foot stool, CONV_Vitra_DmstcChrs_GrandRepos&Ottoman:Grand Repos lounge chair & Ottoman foot stool:327409
In: Level 1
Material: Textile mello black 12, Glide white, 03 aluminium polished
Pset_ManufacturerTypeInformation - ModelReference: 21048600; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - DistanceControl: 0 mm
Dimensions - Area: 3.574 m2; Volume: 1.221 m3
Materials and Finishes - LoungeChairMainMaterial: Textile mello black 12; LoungeChairSecondaryMaterial: 03 aluminium polished
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_GrandRepos&Ottoman: Grand Repos lounge chair & Ottoman foot stool; Family and Type: CONV_Vitra_DmstcChrs_GrandRepos&Ottoman: Grand Repos lounge chair & Ottoman foot stool; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_GrandRepos&Ottoman: Grand Repos lounge chair & Ottoman foot stool; Type Id: CONV_Vitra_DmstcChrs_GrandRepos&Ottoman: Grand Repos lounge chair & Ottoman foot stool; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_Repos&Ottoman; ConvergoRefNr: 0089-1812-0042-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Grand Repos wing chair by Antonio Citterio offers exceptional comfort, particularly when paired with the Ottoman.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Lounge chairs; Uniclass2015Reference: Pr_40_50_12_48; Version: 1; VersionDate: 28/01/2019
Identity Data(Type) - Collection: Repos; Cost: 0; Description: The Grand Repos wing chair by Antonio Citterio offers exceptional comfort, particularly when paired with the Ottoman. The synchronised mechanism concealed beneath the upholstery supports the user at every angle of inclination and can be locked in any position. Once the user is comfortably reclined, the Ottoman provides a soft foot rest for ultimate relaxation.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: Grand Repos lounge chair & Ottoman foot stool; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/165728/storage/master/download/FS%20Repos%20GrandRepos%20PetitRepos-EN.pdf; Type Name: Grand Repos lounge chair & Ottoman foot stool; URL: https://www.vitra.com/en-un/living/product/details/repos-and-ottoman
Materials and Finishes(Type) - LoungeChairTertiaryMaterial: Glide white
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_GrandRepos&Ottoman; Features: n/a; Finish: Chair/body: moulded polyurethane foam with webbed plastic frame and integrated synchronised mechanism with locking device. Seat heights: 410 mm (310 mm with applied load, measured in accordance with EN 1335-1) or 460 mm (360 mm with applied load, measured in accordance with EN 1335-1). Base: four-star base in die-cast aluminium, polished or powder-coated finish. Neck pillow: filled with feathers.; Grade: n/a; Material: Polyurethane foam, polyester fibre, plastic, aluminium, feathers & textile/leather.; ModelNumber: n/a; ModelReference: 21048600; Name: DmstcChrs_GrandRepos&Ottoman; ReplacementCost: n/a; Shape: Sculptured; Size: Chair 740x810x1100/1150 mm & Ottoman: 620x620x400mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
